options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    realtime_scheduling: '1'
    title: Walkie Talkie
  states: {}

blocks:
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '76'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '384000'
  states: {}
- name: selected_channel
  id: variable_qtgui_chooser
  parameters:
    label: Channel
    labels: '["Channel 1", "Channel 2", "Channel 3", "Channel 4", "Channel 5", "Channel 6", "Channel 7", "Channel 8", ]'
    num_opts: '0'
    options: '[0,1, 2,3,4,5,6,7]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: tuning
  id: variable
  parameters:
    value: 446000000+12500+6250-1000
  states: {}
- name: analog_ctcss_squelch_ff_0
  id: analog_ctcss_squelch_ff
  parameters:
    freq: '100'
    gate: 'False'
    len: '0'
    level: '0.01'
    ramp: '0'
    rate: '48000'
  states: {state: disabled}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 6e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '300'
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '20'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '6000'
    decim: '2'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3000'
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_sink_x_0_1_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '8192'
    name: '"Shifted Freq"'
    rate: '100'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_1_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '8192'
    name: '"Shifted Freq"'
    rate: '100'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_1_0_0_1
  id: qtgui_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '8192'
    name: '"Shifted Freq"'
    rate: '100'
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0_1_0_0_1_0
  id: qtgui_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '8192'
    name: '"Shifted Freq"'
    rate: '100'
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: tuning
    gain0: rf_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_ctcss_squelch_ff_0, '0', high_pass_filter_0, '0']
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_nbfm_rx_0, '0', low_pass_filter_0_1_0, '0']
- [analog_nbfm_rx_0, '0', qtgui_sink_x_0_1_0_0_1_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [high_pass_filter_0, '0', qtgui_sink_x_0_1_0_0_1, '0']
- [low_pass_filter_0_1, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_0_1, '0', qtgui_sink_x_0_1_0_0_0, '0']
- [low_pass_filter_0_1_0, '0', analog_ctcss_squelch_ff_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0_1, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0_1_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
