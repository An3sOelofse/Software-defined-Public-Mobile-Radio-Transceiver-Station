options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    realtime_scheduling: '1'
    title: Walkie Talkie
  states: {}

blocks:
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '76'
    value: '40'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    outputmsgname: value
    showports: 'False'
    start: '192000'
    step: '1'
    stop: '56000000'
    value: '384000'
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: Frequency
    outputmsgname: value
    showports: 'False'
    start: '70000000'
    step: '200000'
    stop: '6000000000'
    value: '446006250'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '384000'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: qtgui_sink_x_0_1_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '4096'
    name: '"Shifted Freq"'
    rate: '100'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_1_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '4096'
    name: '"Shifted Freq"'
    rate: '100'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: '384000'
    type: float
    update_time: '0.02'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: tuning
    gain0: '40'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_nbfm_rx_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0_1_0_0_0, '0']
- [uhd_usrp_source_0, '0', analog_simple_squelch_cc_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0_1_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
