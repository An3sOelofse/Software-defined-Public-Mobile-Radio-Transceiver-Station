options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    realtime_scheduling: '1'
    title: Walkie Talkie
  states: {}

blocks:
- name: DCS
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'True'
    pressBackgroundColor: green
    pressFontColor: white
    pressed: '1'
    relBackgroundColor: gray
    relFontColor: white
    released: '0'
    type: int
    value: '1'
  states: {}
- name: PTT
  id: variable_qtgui_push_button
  parameters:
    label: Push To Talk
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '76'
    value: '30'
  states: {}
- name: rf_gain_tx
  id: variable_qtgui_range
  parameters:
    label: Transmit Gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '76'
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '384000'
  states: {}
- name: selected_DCS
  id: variable_qtgui_chooser
  parameters:
    label: DCS Tone
    labels: '["OFF","D023N" ]'
    num_opts: '0'
    options: '[0,1,]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
  states: {}
- name: selected_channel
  id: variable_qtgui_chooser
  parameters:
    label: Channel
    labels: '["Channel 1", "Channel 2", "Channel 3", "Channel 4", "Channel 5", "Channel 6", "Channel 7", "Channel 8", ]'
    num_opts: '0'
    options: '[1, 2,3,4,5,6,7,8]'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: tuning
  id: variable
  parameters:
    value: '446000000'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '24000'
    fh: '-1.0'
    max_dev: 2.5e3
    quad_rate: '384000'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: pipewire
    samp_rate: '48000'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '20000'
    max_iter: '20000'
    scale: 1/20000
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: PTT
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: dcss_generation_0
  id: dcss_generation
  parameters:
    audio_sample_rate: '24000'
    dcs_active: DCS
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, selected_source=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Channel Selector',   # will show up in GRC
                  in_sig=[np.float32,np.float32,np.float32,np.float32,np.float32,np.float32,np.float32,np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.selected_source = selected_source

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[int(self.selected_source)-1]
              return len(output_items[0])
    selected_source: selected_channel
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, selected_dcs_code=0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='DCS Squelch',   # will show up in GRC
                  in_sig=[np.float32,np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.selected_dcs_code = selected_dcs_code

              self.squelch_open = 0

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0][:]
              return len(output_items[0])
    selected_dcs_code: '0'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '300'
    decim: '1'
    gain: '1'
    samp_rate: '24000'
    type: fir_filter_fff
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '6000'
    decim: '1'
    gain: '1'
    samp_rate: '384000'
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '200'
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '150'
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: '1.997'
    type: float
  states: {}
- name: pmr_channel_demod_0
  id: pmr_channel_demod
  parameters:
    channel: '1'
    samp_rate: samp_rate
  states: {}
- name: pmr_channel_demod_0_0
  id: pmr_channel_demod
  parameters:
    channel: '2'
    samp_rate: samp_rate
  states: {}
- name: pmr_channel_demod_0_1
  id: pmr_channel_demod
  parameters:
    channel: '3'
    samp_rate: samp_rate
  states: {}
- name: pmr_channel_demod_0_1_0
  id: pmr_channel_demod
  parameters:
    channel: '4'
    samp_rate: samp_rate
  states: {}
- name: pmr_channel_demod_0_1_1
  id: pmr_channel_demod
  parameters:
    channel: '5'
    samp_rate: samp_rate
  states: {}
- name: pmr_channel_demod_0_1_2
  id: pmr_channel_demod
  parameters:
    channel: '6'
    samp_rate: samp_rate
  states: {}
- name: pmr_channel_demod_0_1_3
  id: pmr_channel_demod
  parameters:
    channel: '7'
    samp_rate: samp_rate
  states: {}
- name: pmr_channel_demod_0_1_4
  id: pmr_channel_demod
  parameters:
    channel: '8'
    samp_rate: samp_rate
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: '200000'
    center_freq0: tuning+6250+(12500*selected_channel)
    gain0: rf_gain_tx*PTT-(1-PTT)*30
    otw: sc16
    samp_rate: '384000'
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: '200000'
    center_freq0: tuning
    gain0: rf_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_nbfm_tx_0, '0', low_pass_filter_0, '0']
- [audio_source_0, '0', mmse_resampler_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_sub_xx_0, '0', low_pass_filter_0_1_0_0_0, '0']
- [dcss_generation_0, '0', analog_nbfm_tx_0, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_0, '0', low_pass_filter_0_1_0_0, '0']
- [epy_block_1, '0', audio_sink_0, '0']
- [high_pass_filter_0, '0', dcss_generation_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [low_pass_filter_0_1_0_0, '0', blocks_moving_average_xx_0, '0']
- [low_pass_filter_0_1_0_0, '0', blocks_sub_xx_0, '0']
- [low_pass_filter_0_1_0_0_0, '0', epy_block_1, '1']
- [mmse_resampler_xx_0, '0', high_pass_filter_0, '0']
- [pmr_channel_demod_0, '0', epy_block_0, '0']
- [pmr_channel_demod_0_0, '0', epy_block_0, '1']
- [pmr_channel_demod_0_1, '0', epy_block_0, '2']
- [pmr_channel_demod_0_1_0, '0', epy_block_0, '3']
- [pmr_channel_demod_0_1_1, '0', epy_block_0, '4']
- [pmr_channel_demod_0_1_2, '0', epy_block_0, '5']
- [pmr_channel_demod_0_1_3, '0', epy_block_0, '6']
- [pmr_channel_demod_0_1_4, '0', epy_block_0, '7']
- [uhd_usrp_source_0, '0', pmr_channel_demod_0, '0']
- [uhd_usrp_source_0, '0', pmr_channel_demod_0_0, '0']
- [uhd_usrp_source_0, '0', pmr_channel_demod_0_1, '0']
- [uhd_usrp_source_0, '0', pmr_channel_demod_0_1_0, '0']
- [uhd_usrp_source_0, '0', pmr_channel_demod_0_1_1, '0']
- [uhd_usrp_source_0, '0', pmr_channel_demod_0_1_2, '0']
- [uhd_usrp_source_0, '0', pmr_channel_demod_0_1_3, '0']
- [uhd_usrp_source_0, '0', pmr_channel_demod_0_1_4, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
