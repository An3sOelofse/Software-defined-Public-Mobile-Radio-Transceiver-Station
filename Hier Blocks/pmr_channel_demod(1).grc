options:
  parameters:
    generate_options: hb
    id: pmr_channel_demod
    output_language: python
    title: PMR Channel Demodulator
  states: {}

blocks:
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 2.5e3
    quad_rate: '384000'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-40'
  states: {}
- name: band_pass_filter_1_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1 + 12500*(channel)
    low_cutoff_freq: 1 + 12500*(channel-1)
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_freqshift_cc_1
  id: blocks_freqshift_cc
  parameters:
    freq: '-12500*(channel-1) -5400'
    sample_rate: samp_rate
  states: {}
- name: channel
  id: parameter
  parameters:
    label: PMR Channel (1-8)
    type: intx
    value: '0'
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '6000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    value: '0'
  states: {}

connections:
- [analog_nbfm_rx_0, '0', pad_sink_1, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [band_pass_filter_1_0, '0', blocks_freqshift_cc_1, '0']
- [blocks_freqshift_cc_1, '0', low_pass_filter_0_1, '0']
- [low_pass_filter_0_1, '0', analog_simple_squelch_cc_0, '0']
- [pad_source_0, '0', band_pass_filter_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
