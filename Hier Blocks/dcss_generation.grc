options:
  parameters:
    author: Andries Oelofse
    generate_options: hb
    id: dcss_generation
    output_language: python
    title: DCSS Tone Generator
  states: {}

blocks:
- name: audio_sample_rate
  id: parameter
  parameters:
    label: Audio Rate
    type: intx
    value: '0'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '150'
    max_iter: '150'
    scale: 1/150
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.07*dcs_active
    maxoutbuf: '10000'
    type: float
  states: {}
- name: dcs_active
  id: parameter
  parameters:
    label: DCS Active/Inactive (1/0)
    type: intx
    value: '0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, dcs_code=0,audio_rate=48000):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='DCS Generator',   # will show up in GRC
                  in_sig=[],
                  out_sig=[np.byte]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.stored_codes = [np.array([0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0]),
                                   np.array([0,1,1,0,0,0,1,1,1,0,0,1,1,0,0,1,0,0,0,0,0,0,1])]
              self.dcs_code = int(dcs_code)
              self.audio_rate = audio_rate
              # self.selected_code = [[0,1,1,0,0,0,1,1,1,0,0,1,1,0,0,1,0,0,0,0,0,0,1]]
              
              self.selected_code = [self.stored_codes[self.dcs_code]]
              self.long_code = np.repeat(self.selected_code,178,axis=1)
              print(self.long_code[0])
              self.lastIndex = 0

          def work(self,input_items, output_items):
              """example: multiply with constant"""
              out = output_items[0]
              length = len(out)

              if(self.lastIndex+length >= 4094-1):
                  self.lastIndex = self.lastIndex % 23 

              out[:] = self.long_code[0][self.lastIndex:self.lastIndex+length]
              self.lastIndex = self.lastIndex + length 

              

             
              return length
    audio_rate: audio_sample_rate
    dcs_code: '1.0'
    maxoutbuf: '4094'
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '200'
    decim: '1'
    gain: '1'
    samp_rate: audio_sample_rate
    type: fir_filter_fff
    width: '20'
    win: window.WIN_HAMMING
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', low_pass_filter_0_0, '0']
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [blocks_char_to_float_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_add_xx_0, '1']
- [epy_block_0, '0', blocks_char_to_float_1, '0']
- [low_pass_filter_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [pad_source_0, '0', blocks_multiply_const_vxx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
