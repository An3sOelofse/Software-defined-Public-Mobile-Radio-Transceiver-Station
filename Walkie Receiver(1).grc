options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '76'
    value: '40'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    outputmsgname: value
    showports: 'False'
    start: '192000'
    step: '1'
    stop: '56000000'
    value: '1920000'
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: Frequency
    outputmsgname: value
    showports: 'False'
    start: '70000000'
    step: '200000'
    stop: '6000000000'
    value: '446000000'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '8'
    audio_pass: '1000'
    audio_stop: '5000'
    chan_rate: '12800'
    deviation: '75000'
    gain: '1.0'
    tau: '1'
  states: {state: disabled}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '384000'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.3'
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '1024'
    name: '"Spectrum Analyzer"'
    rate: '100'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/5
    fc: tuning
    fftsize: '1024'
    name: '"Zoomed"'
    rate: '100'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: tuning
    gain0: rf_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
